DRIDRIVERS:sage-zynqmp = "nouveau"
